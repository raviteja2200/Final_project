# Keil uVision project final_1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: final_1
  c flags: Optim=1
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: final.c
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../utils/: uartstdio.c
    ../../../../sensorlib/rvmdk/: sensorlib.lib
    ../../ek-tm4c1294xl-boostxl-senshub/compdcm_mpu9150/: startup_rvmdk.S
    ../drivers/: buttons.c pinout.c
